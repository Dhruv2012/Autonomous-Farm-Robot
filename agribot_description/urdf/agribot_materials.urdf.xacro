Commit message: red color added

File: agribot_description/urdf/agribot_materials.urdf.xacro (robot description, xacro)
@@ -19,3 +19,6 @@
 		<color rgba="0.7 0.6 0.4 1.0"/>
 	</material>
+	<material name="Red">
+		<color rgba="1.0 0.0 0.0 1.0"/>
+	</material>
 </robot>
